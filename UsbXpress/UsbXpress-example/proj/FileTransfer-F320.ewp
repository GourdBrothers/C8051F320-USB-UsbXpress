# IAR project FileTransfer-F320.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: C8051F320 C8051F320
  ICC8051.CCDefines: _C8051F320_1_
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Silicon Labs\lnk51ew_C8051F320.xcl
  group (top)
    ../src/: FileTransfer.c low_level_init.c
    ../: README
    ../lib/: USBX-F320.r51
