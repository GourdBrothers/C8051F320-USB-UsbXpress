# IAR project FileTransfer-F340.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: C8051F340 C8051F340
  ICC8051.CCDefines: _C8051F34X_
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Silicon Labs\lnk51ew_C8051F340.xcl
  group (top)
    ../src/: FileTransfer.c low_level_init.c
    ../: README
    ../lib/: USBX-F340.r51
